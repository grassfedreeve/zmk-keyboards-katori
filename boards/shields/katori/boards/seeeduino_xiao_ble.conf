## boards/shields/katori/boards/seeeduino_xiao_ble.conf
```kconfig
CONFIG_ZMK_KSCAN_EC_MATRIX_FAKE_OPEN_DRAIN=y
CONFIG_ZMK_KSCAN_EC_MATRIX_THREAD_STACK_SIZE=2048
CONFIG_SHELL_STACK_SIZE=4096
```
